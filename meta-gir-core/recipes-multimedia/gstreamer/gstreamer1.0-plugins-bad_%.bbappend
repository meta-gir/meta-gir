inherit g-ir

include gstreamer1.0-plugins.inc
