inherit g-ir
