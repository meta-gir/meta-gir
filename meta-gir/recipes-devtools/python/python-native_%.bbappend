FILESEXTRAPATHS_prepend := "${FILE_DIRNAME}/${PN}:"

SRC_URI += "file://Fix-build-error-in-g-ir-core.patch"
